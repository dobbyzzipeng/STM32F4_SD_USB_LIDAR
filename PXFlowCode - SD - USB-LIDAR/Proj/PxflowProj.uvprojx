# Keil uVision project PxflowProj.uvprojx, settings and files
target Pxflow (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PxflowProj +hex
  AfterMake: "C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe"  --bin -o ..\Proj\Objects\PxflowProj.bin ..\Proj\Objects\PxflowProj.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS
  c include: ..\CORE;..\FWlib\inc;..\Proj;..\MALLOC;..\HARDWARE;..\SYSTEM;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\msc\inc;..\Math\inc;..\RPLIDAR
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c main.h stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/: myiic.c stmflash.c pwm.c led.c timer.c gps.c dr16.c iwdg.c w25qxx.c spi.c sdio_sdcard.c crc8.c
  group LIDAR
    ../RPLIDAR/: data_process.c laser_data_parser.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: fattester.c exfuns.c
    ../FATFS/src/option/: cc936.c
  group SYSTEM
    ../SYSTEM/: bsp_usart.c usart.c delay.c sys.c
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_usr.c usbd_desc.c usbd_storage_msd.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group MATH
    ../Math/src/: FastMath.c
  group FWlib
    ../FWlib/src/: misc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_sdio.c stm32f4xx_iwdg.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
